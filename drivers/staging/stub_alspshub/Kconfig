## drivers/staging/stub_alspshub/Kconfig
```kconfig
config STUB_ALSPSHUB
    tristate "Stub ALS/PS Hub module"
    default n
    help
      Just for testing purpose.
```
